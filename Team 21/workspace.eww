<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\CSE 211 - Introduction to Embeded Systems\Study\My projects\Lec 9\lec 9.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\mbdd.ewp</path>
    </project>
    <batchBuild />
</workspace>
